#pragma once
#include <stdint.h>

// 自写 5x7 点阵，列优先，每字节最低位为最上一行。
// 仅覆盖本实验用到的 ASCII 字符；未知字符返回问号。
#define FONT5X7_W 5
#define FONT5X7_H 7

static const uint8_t FONT_SPACE[5] = {0x00, 0x00, 0x00, 0x00, 0x00};
static const uint8_t FONT_MINUS[5] = {0x08, 0x08, 0x08, 0x08, 0x08};
static const uint8_t FONT_DOT[5]   = {0x00, 0x00, 0x60, 0x60, 0x00};
static const uint8_t FONT_COLON[5] = {0x00, 0x36, 0x36, 0x00, 0x00};
static const uint8_t FONT_SLASH[5] = {0x20, 0x10, 0x08, 0x04, 0x02};
static const uint8_t FONT_QUESTION[5] = {0x02, 0x01, 0x51, 0x09, 0x06};

static const uint8_t FONT_A[5] = {0x7E, 0x11, 0x11, 0x11, 0x7E};
static const uint8_t FONT_B[5] = {0x7F, 0x49, 0x49, 0x49, 0x36};
static const uint8_t FONT_C[5] = {0x3E, 0x41, 0x41, 0x41, 0x22};
static const uint8_t FONT_D[5] = {0x7F, 0x41, 0x41, 0x22, 0x1C};
static const uint8_t FONT_E[5] = {0x7F, 0x49, 0x49, 0x49, 0x41};
static const uint8_t FONT_F[5] = {0x7F, 0x09, 0x09, 0x09, 0x01};
static const uint8_t FONT_G[5] = {0x3E, 0x41, 0x49, 0x49, 0x7A};
static const uint8_t FONT_H[5] = {0x7F, 0x08, 0x08, 0x08, 0x7F};
static const uint8_t FONT_I[5] = {0x00, 0x41, 0x7F, 0x41, 0x00};
static const uint8_t FONT_J[5] = {0x20, 0x40, 0x41, 0x3F, 0x01};
static const uint8_t FONT_K[5] = {0x7F, 0x08, 0x14, 0x22, 0x41};
static const uint8_t FONT_L[5] = {0x7F, 0x40, 0x40, 0x40, 0x40};
static const uint8_t FONT_M[5] = {0x7F, 0x02, 0x0C, 0x02, 0x7F};
static const uint8_t FONT_N[5] = {0x7F, 0x04, 0x08, 0x10, 0x7F};
static const uint8_t FONT_O[5] = {0x3E, 0x41, 0x41, 0x41, 0x3E};
static const uint8_t FONT_P[5] = {0x7F, 0x09, 0x09, 0x09, 0x06};
static const uint8_t FONT_Q[5] = {0x3E, 0x41, 0x51, 0x21, 0x5E};
static const uint8_t FONT_R[5] = {0x7F, 0x09, 0x19, 0x29, 0x46};
static const uint8_t FONT_S[5] = {0x46, 0x49, 0x49, 0x49, 0x31};
static const uint8_t FONT_T[5] = {0x01, 0x01, 0x7F, 0x01, 0x01};
static const uint8_t FONT_U[5] = {0x3F, 0x40, 0x40, 0x40, 0x3F};
static const uint8_t FONT_V[5] = {0x1F, 0x20, 0x40, 0x20, 0x1F};
static const uint8_t FONT_W[5] = {0x3F, 0x40, 0x38, 0x40, 0x3F};
static const uint8_t FONT_X[5] = {0x63, 0x14, 0x08, 0x14, 0x63};
static const uint8_t FONT_Y[5] = {0x07, 0x08, 0x70, 0x08, 0x07};
static const uint8_t FONT_Z[5] = {0x61, 0x51, 0x49, 0x45, 0x43};

static const uint8_t FONT_0[5] = {0x3E, 0x51, 0x49, 0x45, 0x3E};
static const uint8_t FONT_1[5] = {0x00, 0x42, 0x7F, 0x40, 0x00};
static const uint8_t FONT_2[5] = {0x42, 0x61, 0x51, 0x49, 0x46};
static const uint8_t FONT_3[5] = {0x21, 0x41, 0x45, 0x4B, 0x31};
static const uint8_t FONT_4[5] = {0x18, 0x14, 0x12, 0x7F, 0x10};
static const uint8_t FONT_5[5] = {0x27, 0x45, 0x45, 0x45, 0x39};
static const uint8_t FONT_6[5] = {0x3C, 0x4A, 0x49, 0x49, 0x30};
static const uint8_t FONT_7[5] = {0x01, 0x71, 0x09, 0x05, 0x03};
static const uint8_t FONT_8[5] = {0x36, 0x49, 0x49, 0x49, 0x36};
static const uint8_t FONT_9[5] = {0x06, 0x49, 0x49, 0x29, 0x1E};

static inline const uint8_t *font5x7_glyph(char c) {
    if (c >= 'a' && c <= 'z') c = (char)(c - 'a' + 'A');
    if (c >= 'A' && c <= 'Z') {
        static const uint8_t *letters[26] = {
            FONT_A, FONT_B, FONT_C, FONT_D, FONT_E, FONT_F, FONT_G, FONT_H, FONT_I,
            FONT_J, FONT_K, FONT_L, FONT_M, FONT_N, FONT_O, FONT_P, FONT_Q, FONT_R,
            FONT_S, FONT_T, FONT_U, FONT_V, FONT_W, FONT_X, FONT_Y, FONT_Z};
        return letters[c - 'A'];
    }
    if (c >= '0' && c <= '9') {
        static const uint8_t *digits[10] = {FONT_0, FONT_1, FONT_2, FONT_3, FONT_4,
                                            FONT_5, FONT_6, FONT_7, FONT_8, FONT_9};
        return digits[c - '0'];
    }
    switch (c) {
        case ' ': return FONT_SPACE;
        case '-': return FONT_MINUS;
        case '.': return FONT_DOT;
        case ':': return FONT_COLON;
        case '/': return FONT_SLASH;
        default: return FONT_QUESTION;
    }
}
